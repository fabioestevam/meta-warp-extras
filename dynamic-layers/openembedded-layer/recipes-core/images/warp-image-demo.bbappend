IMAGE_INSTALL_append_warp = " \
	memtester \
	civetweb toybox \
	"
